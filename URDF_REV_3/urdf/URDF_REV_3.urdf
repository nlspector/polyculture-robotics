Commit message: add mimic

File: URDF_REV_3/urdf/URDF_REV_3.urdf (robot description, URDF)
Before this commit: robot URDF_REV_3, 9 links, 8 joints
Joints:
- joint joint_7: mimic (none) -> joint=joint_6 multiplier=-1 offset=0
